# IAR project DRIVE.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: communicator.c communicator.h drive.c drive.h main.c tests.c tests.h
  group COMMON MODULES
    ../../MODULES/: capture.c capture.h encoder.c encoder.h hal.c hal.h ring_buffer16.c ring_buffer16.h ring_buffer8.c ring_buffer8.h serial.c serial.h timing.c timing.h
